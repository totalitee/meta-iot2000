require linux-yocto.inc
SRC_URI += " \
    file://defconfig \
    file://iot2000.cfg"
